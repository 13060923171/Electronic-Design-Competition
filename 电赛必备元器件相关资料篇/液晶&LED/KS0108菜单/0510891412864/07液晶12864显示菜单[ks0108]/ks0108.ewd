<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>1</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>10</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>Driver</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>CSVariantProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>DDFile</name>
          <state>none</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>Port</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Baud</name>
          <version>0</version>
          <state>5</state>
        </option>
        <option>
          <name>Parity</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>DataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>StopBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Handshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>DoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>LogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>SuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>FastDownload</name>
          <state>1</state>
        </option>
        <option>
          <name>TargetCCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OCEnhancedCore</name>
          <state>1</state>
        </option>
        <option>
          <name>OC64BitDoubles</name>
          <state>1</state>
        </option>
        <option>
          <name>HighSpeed</name>
          <state>1</state>
        </option>
        <option>
          <name>SingleStepTimers</name>
          <state>0</state>
        </option>
        <option>
          <name>RestoreEEPROM</name>
          <state>0</state>
        </option>
        <option>
          <name>ComPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>SuppLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>ConsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileSlave</name>
          <state></state>
        </option>
        <option>
          <name>JtagIceDefaultCom</name>
          <state>1</state>
        </option>
        <option>
          <name>JtagIceComPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceSuppLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceConsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceJtagFreqRadio</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceJtagFreqManually</name>
          <state>100000</state>
        </option>
        <option>
          <name>JtagIceJtagFreq</name>
          <version>0</version>
          <state>5</state>
        </option>
        <option>
          <name>JtagIceJtagDeviceBefore</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceJtagDeviceAfter</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceJtagInstrBitsBefore</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceJtagInstrBitsAfter</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceDaisyChain</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagDebugTimers</name>
          <state>1</state>
        </option>
        <option>
          <name>JtagDebugEeprom</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagDebugReset</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagDebugFuses</name>
          <state>0</state>
        </option>
        <option>
          <name>RunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>RunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CPluginDll</name>
          <state>Browse to C-SPY plugin</state>
        </option>
        <option>
          <name>newDDFileOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CSVariantEepromSize</name>
          <state>0</state>
        </option>
        <option>
          <name>CSVariant64KFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>CThirdPartyDriverDll</name>
          <state>Browse to your Third party driver</state>
        </option>
        <option>
          <name>CThirdPartySuppress</name>
          <state>0</state>
        </option>
        <option>
          <name>CThirdPartyVerify</name>
          <state>0</state>
        </option>
        <option>
          <name>CThirdPartyLogFileCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CThirdPartyLogFileEditB</name>
          <state>$TOOLKIT_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>Ice200ResetDelayList</name>
          <version>8</version>
          <state>0</state>
        </option>
        <option>
          <name>Ice200downloadToData</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIcedownloadToData</name>
          <state>0</state>
        </option>
        <option>
          <name>CCRdownloadToData</name>
          <state>0</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>10</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>Driver</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>CSVariantProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>DDFile</name>
          <state></state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>Port</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Baud</name>
          <version>0</version>
          <state>5</state>
        </option>
        <option>
          <name>Parity</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>DataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>StopBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Handshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>DoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>LogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>SuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>FastDownload</name>
          <state>1</state>
        </option>
        <option>
          <name>TargetCCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OCEnhancedCore</name>
          <state>1</state>
        </option>
        <option>
          <name>OC64BitDoubles</name>
          <state>1</state>
        </option>
        <option>
          <name>HighSpeed</name>
          <state>1</state>
        </option>
        <option>
          <name>SingleStepTimers</name>
          <state>0</state>
        </option>
        <option>
          <name>RestoreEEPROM</name>
          <state>0</state>
        </option>
        <option>
          <name>ComPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>SuppLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>ConsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileSlave</name>
          <state></state>
        </option>
        <option>
          <name>JtagIceDefaultCom</name>
          <state>1</state>
        </option>
        <option>
          <name>JtagIceComPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceSuppLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceConsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceJtagFreqRadio</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceJtagFreqManually</name>
          <state>100000</state>
        </option>
        <option>
          <name>JtagIceJtagFreq</name>
          <version>0</version>
          <state>5</state>
        </option>
        <option>
          <name>JtagIceJtagDeviceBefore</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceJtagDeviceAfter</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceJtagInstrBitsBefore</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceJtagInstrBitsAfter</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIceDaisyChain</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagDebugTimers</name>
          <state>1</state>
        </option>
        <option>
          <name>JtagDebugEeprom</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagDebugReset</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagDebugFuses</name>
          <state>0</state>
        </option>
        <option>
          <name>RunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>RunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CPluginDll</name>
          <state>Browse to C-SPY plugin</state>
        </option>
        <option>
          <name>newDDFileOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CSVariantEepromSize</name>
          <state>0</state>
        </option>
        <option>
          <name>CSVariant64KFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>CThirdPartyDriverDll</name>
          <state>Browse to your Third party driver</state>
        </option>
        <option>
          <name>CThirdPartySuppress</name>
          <state>0</state>
        </option>
        <option>
          <name>CThirdPartyVerify</name>
          <state>0</state>
        </option>
        <option>
          <name>CThirdPartyLogFileCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CThirdPartyLogFileEditB</name>
          <state>$TOOLKIT_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>Ice200ResetDelayList</name>
          <version>8</version>
          <state>0</state>
        </option>
        <option>
          <name>Ice200downloadToData</name>
          <state>0</state>
        </option>
        <option>
          <name>JtagIcedownloadToData</name>
          <state>0</state>
        </option>
        <option>
          <name>CCRdownloadToData</name>
          <state>0</state>
        </option>
      </data>
    </settings>
  </configuration>
</project>


