# Keil uVision project 控制系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: 控制系统 +hex
  c flags: Optimize=9
  group Source Group 1
    ./: STARTUP.A51 控制系统.c
